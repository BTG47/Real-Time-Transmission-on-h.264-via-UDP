<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_bladerf</value></param>
<param><key>title</key><value>BladeRF TX over ZMQ PDU (H.264 via GNU Radio)</value></param>
<param><key>description</key><value>Reference TX flowgraph: receives an H.264 PMT PDU (pmt::serialize_str(cons(dict, u8vector))) over ZMQ PULL on tcp://127.0.0.1:5555 and transmits it GMSK-modulated with a BladeRF at 2.45 GHz / 20 Msps.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>output_language</key><value>python</value></param>
<param><key>realtime</key><value>false</value></param>
<param><key>hier_block_src_path</key><value></value></param>
<param><key>comment</key><value>Reference TX for TRANSPORT="radio". Start after RX flowgraph has bound 5556 and after python radio/reciever_radio.py is running.</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5555</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>mode</key><value>connect</value></param>
<param><key>pass_tags</key><value>False</value></param>
<param><key>hwm</key><value>-1</value></param>
</block>
<block>
<key>blks2_pdu_to_tagged_stream</key>
<param><key>id</key><value>blks2_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>bt</key><value>0.3</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>bladerf_sink</key>
<param><key>id</key><value>bladerf_sink_0</value></param>
<param><key>sample_rate</key><value>20e6</value></param>
<param><key>center_freq</key><value>2.45e9</value></param>
<param><key>gain</key><value>40</value></param>
</block>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>blks2_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blks2_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>bladerf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
