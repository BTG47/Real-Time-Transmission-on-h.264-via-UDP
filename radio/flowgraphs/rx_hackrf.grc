<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_hackrf</value></param>
<param><key>title</key><value>HackRF RX over ZMQ PDU (H.264 via GNU Radio)</value></param>
<param><key>description</key><value>Reference RX flowgraph: receives GMSK at 2.45 GHz / 20 Msps with a HackRF via gr-osmosdr, decodes the tagged stream and forwards the PMT PDU (pmt::serialize_str(cons(dict, u8vector))) over ZMQ PUSH bound to tcp://127.0.0.1:5556.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>output_language</key><value>python</value></param>
<param><key>realtime</key><value>false</value></param>
<param><key>hier_block_src_path</key><value></value></param>
<param><key>comment</key><value>Reference RX for TRANSPORT="radio". Must bind 5556 before python radio/reciever_radio.py connects to it.</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>args</key><value>hackrf</value></param>
<param><key>sample_rate</key><value>20e6</value></param>
<param><key>freq</key><value>2.45e9</value></param>
<param><key>bandwidth</key><value>20e6</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>zeromq_push_msg_sink</key>
<param><key>id</key><value>zeromq_push_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>mode</key><value>bind</value></param>
<param><key>pass_tags</key><value>False</value></param>
<param><key>hwm</key><value>-1</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>zeromq_push_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
